#include "console.h"
#include "kmem.h"       /* KW_RXHEAD / KW_RXTAIL / KW_RXBUF (the ring filled by the ISR in crt0.s) */
#include "include/hw.h"

/* Layer 1 of the console: the link port of the TI-84 Plus through its link assist (one byte at a time,
 * the same hardware the calculator uses to talk to a PC). Receive is interrupt driven (crt0.s fills the
 * KW_RXBUF ring), transmit is polled. */

__sfr __at TI_PORT_LINK_ASSIST_STATUS LASTATUS;
__sfr __at TI_PORT_LINK_ASSIST_TX     LATX;

/* ---- LCD (T6A04, 96x64): a 16 x 8 text screen of 6x8 cells in the 6-bit word mode. ----
 *   One data byte = 6 pixels of one row (bit 5 = leftmost). The vertical counter (X) auto-increments, so a
 *   character is a Y/X setup followed by 8 data bytes. Scrolling moves the display start line Z by 8. */
__sfr __at 0x10 LCDCMD;
__sfr __at 0x11 LCDDATA;

static const unsigned char font[95 * 5] = {   /* ASCII 0x20-0x7E, 5 columns, bit 0 = the top row */
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00,
    0x14, 0x7F, 0x14, 0x7F, 0x14, 0x24, 0x2A, 0x7F, 0x2A, 0x12, 0x23, 0x13, 0x08, 0x64, 0x62,
    0x36, 0x49, 0x56, 0x20, 0x50, 0x00, 0x08, 0x07, 0x03, 0x00, 0x00, 0x1C, 0x22, 0x41, 0x00,
    0x00, 0x41, 0x22, 0x1C, 0x00, 0x2A, 0x1C, 0x7F, 0x1C, 0x2A, 0x08, 0x08, 0x3E, 0x08, 0x08,
    0x00, 0x80, 0x70, 0x30, 0x00, 0x08, 0x08, 0x08, 0x08, 0x08, 0x00, 0x00, 0x60, 0x60, 0x00,
    0x20, 0x10, 0x08, 0x04, 0x02, 0x3E, 0x51, 0x49, 0x45, 0x3E, 0x00, 0x42, 0x7F, 0x40, 0x00,
    0x72, 0x49, 0x49, 0x49, 0x46, 0x21, 0x41, 0x49, 0x4D, 0x33, 0x18, 0x14, 0x12, 0x7F, 0x10,
    0x27, 0x45, 0x45, 0x45, 0x39, 0x3C, 0x4A, 0x49, 0x49, 0x31, 0x41, 0x21, 0x11, 0x09, 0x07,
    0x36, 0x49, 0x49, 0x49, 0x36, 0x46, 0x49, 0x49, 0x29, 0x1E, 0x00, 0x00, 0x14, 0x00, 0x00,
    0x00, 0x40, 0x34, 0x00, 0x00, 0x00, 0x08, 0x14, 0x22, 0x41, 0x14, 0x14, 0x14, 0x14, 0x14,
    0x00, 0x41, 0x22, 0x14, 0x08, 0x02, 0x01, 0x59, 0x09, 0x06, 0x3E, 0x41, 0x5D, 0x59, 0x4E,
    0x7C, 0x12, 0x11, 0x12, 0x7C, 0x7F, 0x49, 0x49, 0x49, 0x36, 0x3E, 0x41, 0x41, 0x41, 0x22,
    0x7F, 0x41, 0x41, 0x41, 0x3E, 0x7F, 0x49, 0x49, 0x49, 0x41, 0x7F, 0x09, 0x09, 0x09, 0x01,
    0x3E, 0x41, 0x41, 0x51, 0x73, 0x7F, 0x08, 0x08, 0x08, 0x7F, 0x00, 0x41, 0x7F, 0x41, 0x00,
    0x20, 0x40, 0x41, 0x3F, 0x01, 0x7F, 0x08, 0x14, 0x22, 0x41, 0x7F, 0x40, 0x40, 0x40, 0x40,
    0x7F, 0x02, 0x1C, 0x02, 0x7F, 0x7F, 0x04, 0x08, 0x10, 0x7F, 0x3E, 0x41, 0x41, 0x41, 0x3E,
    0x7F, 0x09, 0x09, 0x09, 0x06, 0x3E, 0x41, 0x51, 0x21, 0x5E, 0x7F, 0x09, 0x19, 0x29, 0x46,
    0x26, 0x49, 0x49, 0x49, 0x32, 0x03, 0x01, 0x7F, 0x01, 0x03, 0x3F, 0x40, 0x40, 0x40, 0x3F,
    0x1F, 0x20, 0x40, 0x20, 0x1F, 0x3F, 0x40, 0x38, 0x40, 0x3F, 0x63, 0x14, 0x08, 0x14, 0x63,
    0x03, 0x04, 0x78, 0x04, 0x03, 0x61, 0x59, 0x49, 0x4D, 0x43, 0x00, 0x7F, 0x41, 0x41, 0x41,
    0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x41, 0x41, 0x7F, 0x00, 0x04, 0x02, 0x01, 0x02, 0x04,
    0x40, 0x40, 0x40, 0x40, 0x40, 0x00, 0x03, 0x07, 0x08, 0x00, 0x20, 0x54, 0x54, 0x78, 0x40,
    0x7F, 0x28, 0x44, 0x44, 0x38, 0x38, 0x44, 0x44, 0x44, 0x28, 0x38, 0x44, 0x44, 0x28, 0x7F,
    0x38, 0x54, 0x54, 0x54, 0x18, 0x00, 0x08, 0x7E, 0x09, 0x02, 0x18, 0xA4, 0xA4, 0x9C, 0x78,
    0x7F, 0x08, 0x04, 0x04, 0x78, 0x00, 0x44, 0x7D, 0x40, 0x00, 0x20, 0x40, 0x40, 0x3D, 0x00,
    0x7F, 0x10, 0x28, 0x44, 0x00, 0x00, 0x41, 0x7F, 0x40, 0x00, 0x7C, 0x04, 0x78, 0x04, 0x78,
    0x7C, 0x08, 0x04, 0x04, 0x78, 0x38, 0x44, 0x44, 0x44, 0x38, 0xFC, 0x18, 0x24, 0x24, 0x18,
    0x18, 0x24, 0x24, 0x18, 0xFC, 0x7C, 0x08, 0x04, 0x04, 0x08, 0x48, 0x54, 0x54, 0x54, 0x24,
    0x04, 0x04, 0x3F, 0x44, 0x24, 0x3C, 0x40, 0x40, 0x20, 0x7C, 0x1C, 0x20, 0x40, 0x20, 0x1C,
    0x3C, 0x40, 0x30, 0x40, 0x3C, 0x44, 0x28, 0x10, 0x28, 0x44, 0x4C, 0x90, 0x90, 0x90, 0x7C,
    0x44, 0x64, 0x54, 0x4C, 0x44, 0x00, 0x08, 0x36, 0x41, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00,
    0x00, 0x41, 0x36, 0x08, 0x00, 0x02, 0x01, 0x02, 0x04, 0x02,
};

static unsigned char lcd_col, lcd_row, lcd_scrolled, lcd_esc;   /* cursor, scrolled once, ESC sequence state */

static void lcd_glyph(unsigned char col, unsigned char row, unsigned char c)
{
    const unsigned char *g = font + (unsigned)(c - 0x20) * 5;
    unsigned char r, k, v;

    LCDCMD = 0x20 | col;
    LCDCMD = 0x80 | (row << 3);
    for (r = 0; r < 8; r++) {
        v = 0;
        for (k = 0; k < 5; k++)
            if ((g[k] >> r) & 1)
                v |= 0x20 >> k;
        LCDDATA = v;
    }
}

static void lcd_clear_row(unsigned char row)
{
    unsigned char col;
    for (col = 0; col < 16; col++)
        lcd_glyph(col, row, 0x20);
}

void lcd_init(void)
{
    LCDCMD = 0x00;          /* 6-bit word length */
    LCDCMD = 0x05;          /* the X counter counts up */
    LCDCMD = 0x03;          /* display on */
    LCDCMD = 0xC0 | 0x18;   /* contrast */
    LCDCMD = 0x40;          /* Z = 0 */
    for (lcd_row = 0; lcd_row < 8; lcd_row++)
        lcd_clear_row(lcd_row);
    lcd_row = 0;
}

static void lcd_newline(void)
{
    lcd_col = 0;
    if (lcd_row == 7)
        lcd_scrolled = 1;
    lcd_row = (lcd_row + 1) & 7;
    if (lcd_scrolled) {
        lcd_clear_row(lcd_row);
        LCDCMD = 0x40 | (((lcd_row + 1) & 7) << 3);
    }
}

static void lcd_putc(unsigned char c)
{
    if (lcd_esc) {          /* swallow ESC [ ... <letter> (a 16x8 screen cannot do cursor addressing) */
        if (c != '[' && c >= '@')
            lcd_esc = 0;
        return;
    }
    if (c == 0x1B) { lcd_esc = 1; return; }
    if (c == '\r') { lcd_col = 0; return; }
    if (c == '\n') { lcd_newline(); return; }
    if (c < 0x20 || c > 0x7E) return;
    lcd_glyph(lcd_col, lcd_row, c);
    if (++lcd_col == 16)
        lcd_newline();
}

void con_putc(char c)
{
    while (!(LASTATUS & 0x20)) {}	/* wait for tx_ready */
    LATX = c;
    lcd_putc((unsigned char)c);
}

int con_rx_ready(void)
{
    return *(volatile unsigned char *)KW_RXHEAD !=
           *(volatile unsigned char *)KW_RXTAIL;
}

/* Take one byte from the ring. Call it only when con_rx_ready() is true (the same contract as z80board). */
unsigned char con_getc(void)
{
    unsigned char t = *(volatile unsigned char *)KW_RXTAIL;
    unsigned char c = ((volatile unsigned char *)KW_RXBUF)[t];

    *(volatile unsigned char *)KW_RXTAIL = (t + 1) & (KW_RXBUF_SIZE - 1);
    return c;
}
